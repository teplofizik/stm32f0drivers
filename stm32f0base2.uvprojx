# Keil uVision project stm32f0base2.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F071RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0base +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: THOTO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group core
    ./source/: todo.txt system_stm32f0xx.c startup_stm32f0xx.s types.h drivers.h drivers.c bsp.c bsp.h main.c
  group drivers
    ./source/drivers/: driver.c driver.h clock.c clock.h gpio.c gpio.h system.c system.h systick.c systick.h adc.c adc.h dac.h dac.c dma.c dma.h uart.c uart.h activity.c activity.h memory.c memory.h flash.c flash.h exti.c exti.h pwm_tables.c timer.c timer.h ledpwm.c ledpwm.h i2c_slave.c i2c_slave.h i2c.c i2c.h i2c_master.c i2c_master.h touch.c touch.h spi.c spi.h ledfastpwm.c ledfastpwm.h softuartrx.c softuartrx.h uuid.c uuid.h finetimer.c finetimer.h
  group main
    ./source/main/: test.c test.h adctest.c uarttest.c thototest.c dmxtxtest.c waveform.c dactest.c pwmtest.c i2cstest.c i2mtest.c spitest.c
  group bsp
    ./source/bsp/: led.c led.h button.c button.h
  group app
    ./source/app/: app.c app.h
  group thoto
    ./source/thoto/: api.c config.h core.s error_codes.h error_handlers.s event.c event.h internal.c internal.h process.c process.h scheduler.c svc.c svc.h svc_handlers.c thoto.c thoto.h
  group upgrade
    ./source/upgrade/: ram_upgrade.c upgrade.c upgrade.h
  group settings
    ./source/settings/: settings.c settings.h settings_blocks.c settings_blocks.h settings_ll.c settings_ll.h
software components: CMSIS:CORE 5.0.1
